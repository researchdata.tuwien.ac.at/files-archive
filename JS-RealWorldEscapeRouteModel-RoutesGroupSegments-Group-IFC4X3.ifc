Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: no description
File name: Testname
Written by: web-ifc-export
Comment: STEP Physical File produced by: IFCjs WebIfc 0.0.42 * Module: web-ifc/IfcLoader * Version: 0.0.42 * Source: https://github.com/IFCjs/web-ifc * Issues: https://github.com/IFCjs/web-ifc/issues

# IfcSite, Site
RefLatitude: 48, 14, 21, 681555; RefLongitude: 16, 25, 58, 549550; RefElevation: 159.13 m

# IfcBuilding, Building
ElevationOfRefHeight: 0 m

# IfcGroup (12)
Name | EscapeRouteLength (m) | PeopleOfRoute | StartLocation
EscapeRoute Door E2-08, 1. Path | 0 | 3 | Door E2-08, 1. Path
EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path | 10.5531 | 20 | Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path | 3.24503 | 20 | Space KIWA[A_1_U1_A01_014], 1. Path
EscapeRoute Door E1-03, 1. Path | 0 | 2 | Door E1-03, 1. Path
EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path | 2.73703 | 20 | Space E-Technik[A_1_U1_A01_015], 1. Path
EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path | 9.45222 | 20 | Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path | 20.012 | 20 | Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRoute Door E1-08, 1. Path | 0 | 4 | Door E1-08, 1. Path
EscapeRoute Door E0-03, 1. Path | 0 | 2 | Door E0-03, 1. Path
EscapeRoute Door E3-01, 1. Path | 0 | 3 | Door E3-01, 1. Path
EscapeRoute Door E0-08, 1. Path | 0 | 4 | Door E0-08, 1. Path
EscapeRoute Door E2-03, 1. Path | 0 | 2 | Door E2-03, 1. Path

# IfcSpatialZone (122)
PredefinedType: TRANSPORT
Name | CumulativePeople | Length (m) | Group
EscapeRouteSegment00 | 3 | 0.5 | EscapeRoute Door E2-08, 1. Path
EscapeRouteSegment01 | 3 | 2.34793 | EscapeRoute Door E2-08, 1. Path
EscapeRouteSegment02 | 8 | 0.622614 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment03 | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment04 | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment05 | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment06 | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment07 | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment08 | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment09 | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment010 | 8 | 0.644771 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment011 | 8 | 1.38589 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment012 | 8 | 0.635 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment013 | 8 | 0.308272 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment014 | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment015 | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment016 | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment017 | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment018 | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment019 | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment020 | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment021 | 8 | 0.338935 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment022 | 8 | 0.62149 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment023 | 8 | 1.3829 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment024 | 14 | 0.622614 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment025 | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment026 | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment027 | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment028 | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment029 | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment030 | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment031 | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment032 | 14 | 0.644771 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment033 | 14 | 1.38589 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment034 | 14 | 0.635 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment035 | 14 | 0.308272 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment036 | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment037 | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment038 | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment039 | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment040 | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment041 | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment042 | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment043 | 14 | 0.338935 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment044 | 14 | 0.62149 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment045 | 14 | 0.497467 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment046 | 120 | 0.5 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E0-03, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E0-08, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment10 | 20 | 7.32272 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRouteSegment11 | 20 | 2.73041 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRouteSegment12 | 20 | 1 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRouteSegment13 | 20 | 1.9887 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRouteSegment14 | 100 | 0.644771 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment15 | 100 | 0.295107 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment16 | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment17 | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment18 | 100 | 0.3036 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment19 | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment110 | 100 | 0.3036 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment111 | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment112 | 100 | 0.303018 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment113 | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment114 | 100 | 0.634999 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment115 | 100 | 1.36012 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment116 | 100 | 0.64477 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment117 | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment118 | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment119 | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment120 | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment121 | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment122 | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment123 | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment124 | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment125 | 100 | 0.622614 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment126 | 100 | 1.79488 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment20 | 20 | 2.74503 | EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path
EscapeRouteSegment21 | 20 | 1 | EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path
EscapeRouteSegment22 | 20 | 3.35393 | EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path
EscapeRouteSegment30 | 2 | 0.5 | EscapeRoute Door E1-03, 1. Path
EscapeRouteSegment31 | 2 | 1.63483 | EscapeRoute Door E1-03, 1. Path
EscapeRouteSegment40 | 20 | 2.23703 | EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path
EscapeRouteSegment41 | 40 | 1 | EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment42 | 40 | 3.26888 | EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment50 | 20 | 6.38723 | EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment51 | 20 | 1 | EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment52 | 20 | 1.56499 | EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment60 | 20 | 5.27227 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment61 | 20 | 0.0282843 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment62 | 20 | 14.2115 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment63 | 20 | 1 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment64 | 20 | 3.82079 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment70 | 4 | 0.5 | EscapeRoute Door E1-08, 1. Path
EscapeRouteSegment71 | 4 | 2.34813 | EscapeRoute Door E1-08, 1. Path
EscapeRouteSegment80 | 2 | 0.5 | EscapeRoute Door E0-03, 1. Path
EscapeRouteSegment81 | 2 | 2.9617 | EscapeRoute Door E0-03, 1. Path
EscapeRouteSegment90 | 3 | 0.5 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment91 | 3 | 1.23976 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment92 | 3 | 0.622614 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment93 | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment94 | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment95 | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment96 | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment97 | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment98 | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment99 | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment910 | 3 | 0.644771 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment911 | 3 | 1.38589 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment912 | 3 | 0.635 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment913 | 3 | 0.308272 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment914 | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment915 | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment916 | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment917 | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment918 | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment919 | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment920 | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment921 | 3 | 0.338935 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment922 | 3 | 0.62149 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment923 | 3 | 1.3829 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment100 | 4 | 0.5 | EscapeRoute Door E0-08, 1. Path
EscapeRouteSegment101 | 4 | 3.89807 | EscapeRoute Door E0-08, 1. Path
EscapeRouteSegment110 | 2 | 0.5 | EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment111 | 2 | 1.63569 | EscapeRoute Door E2-03, 1. Path

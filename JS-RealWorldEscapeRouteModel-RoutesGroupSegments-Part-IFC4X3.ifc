Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: no description
File name: Testname
Written by: web-ifc-export
Comment: STEP Physical File produced by: IFCjs WebIfc 0.0.42 * Module: web-ifc/IfcLoader * Version: 0.0.42 * Source: https://github.com/IFCjs/web-ifc * Issues: https://github.com/IFCjs/web-ifc/issues

# IfcSite, Site
RefLatitude: 48, 14, 21, 681555; RefLongitude: 16, 25, 58, 549550; RefElevation: 159.13 m

# IfcBuilding, Building
ElevationOfRefHeight: 0 m

# IfcBuildingElementPart (122)
Name | In | CumulativePeople | Length (m)
 | DG1 | 3 | 0.5
 | DG1 | 3 | 2.34793
 | DG1 | 8 | 0.622614
 | DG1 | 8 | 0.307697
 | DG1 | 8 | 0.307696
6 x  | OG1 | 8 | 0.307697
6 x  | OG1 | 8 | 0.307696
 | OG1 | 8 | 0.644771
 | OG1 | 8 | 1.38589
 | OG1 | 8 | 0.635
 | OG1 | 8 | 0.308272
 | OG1 | 8 | 0.338935
 | OG1 | 8 | 0.62149
 | OG1 | 8 | 1.3829
 | OG1 | 14 | 0.622614
 | OG1 | 14 | 0.307697
 | OG1 | 14 | 0.307696
6 x  | EG | 14 | 0.307697
6 x  | EG | 14 | 0.307696
 | EG | 14 | 0.644771
 | EG | 14 | 1.38589
 | EG | 14 | 0.635
 | EG | 14 | 0.308272
 | EG | 14 | 0.338935
 | EG | 14 | 0.62149
 | EG | 14 | 0.497467
 | EG | 120 | 0.5
 | UG1 | 20 | 7.32272
 | UG1 | 20 | 2.73041
4 x  | UG1 | 20 | 1
 | UG1 | 20 | 1.9887
 | UG1 | 100 | 0.644771
 | UG1 | 100 | 0.295107
5 x  | UG1 | 100 | 0.303019
7 x  | UG1 | 100 | 0.303601
2 x  | UG1 | 100 | 0.3036
 | UG1 | 100 | 0.303018
 | UG1 | 100 | 0.634999
 | UG1 | 100 | 1.36012
 | UG1 | 100 | 0.64477
 | EG | 100 | 0.303601
 | EG | 100 | 0.622614
 | EG | 100 | 1.79488
 | UG1 | 20 | 2.74503
 | UG1 | 20 | 3.35393
 | OG1 | 2 | 0.5
 | OG1 | 2 | 1.63483
 | UG1 | 20 | 2.23703
 | UG1 | 40 | 1
 | UG1 | 40 | 3.26888
 | UG1 | 20 | 6.38723
 | UG1 | 20 | 1.56499
 | UG1 | 20 | 5.27227
 | UG1 | 20 | 0.0282843
 | UG1 | 20 | 14.2115
 | UG1 | 20 | 3.82079
 | OG1 | 4 | 0.5
 | OG1 | 4 | 2.34813
 | EG | 2 | 0.5
 | EG | 2 | 2.9617
 | DG2 | 3 | 0.5
 | DG2 | 3 | 1.23976
 | DG2 | 3 | 0.622614
 | DG2 | 3 | 0.307697
 | DG2 | 3 | 0.307696
6 x  | DG1 | 3 | 0.307697
6 x  | DG1 | 3 | 0.307696
 | DG1 | 3 | 0.644771
 | DG1 | 3 | 1.38589
 | DG1 | 3 | 0.635
 | DG1 | 3 | 0.308272
 | DG1 | 3 | 0.338935
 | DG1 | 3 | 0.62149
 | DG1 | 3 | 1.3829
 | EG | 4 | 0.5
 | EG | 4 | 3.89807
 | DG1 | 2 | 0.5
 | DG1 | 2 | 1.63569

# IfcBuildingElementProxy (12)
Name | In | EscapeRouteLength (m) | PeopleOfRoute | StartLocation
EscapeRoute Door E2-08, 1. Path | DG1 | 0 | 3 | Door E2-08, 1. Path
EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path | UG1 | 10.5531 | 20 | Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path | UG1 | 3.24503 | 20 | Space KIWA[A_1_U1_A01_014], 1. Path
EscapeRoute Door E1-03, 1. Path | OG1 | 0 | 2 | Door E1-03, 1. Path
EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path | UG1 | 2.73703 | 20 | Space E-Technik[A_1_U1_A01_015], 1. Path
EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path | UG1 | 9.45222 | 20 | Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path | UG1 | 20.012 | 20 | Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRoute Door E1-08, 1. Path | OG1 | 0 | 4 | Door E1-08, 1. Path
EscapeRoute Door E0-03, 1. Path | EG | 0 | 2 | Door E0-03, 1. Path
EscapeRoute Door E3-01, 1. Path | DG2 | 0 | 3 | Door E3-01, 1. Path
EscapeRoute Door E0-08, 1. Path | EG | 0 | 4 | Door E0-08, 1. Path
EscapeRoute Door E2-03, 1. Path | DG1 | 0 | 2 | Door E2-03, 1. Path

Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [CoordinationView]
File name: Py-RealWorldEscapeRouteModel-RoutesGroupSegments-Group
Time: 2024-06-26T15:51:24
Author: Matthias Haselberger
Organization: TU Wien
Written by: IfcOpenShell
Made in: IfcOpenShell

# IfcSite, Site
RefLatitude: 48, 21, 14, 681555; RefLongitude: 16, 58, 25, 549550; RefElevation: 159.13 m

# IfcGroup (12)
Name | StartLocation | EscapeRouteLength (m) | PeopleOfRoute
EscapeRoute Door E2-08, 1. Path | Door E2-08, 1. Path | 0 | 3
EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path | Space Einstellräume[A_1_U1_A01_013], 1. Path | 10.55 | 20
EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path | Space KIWA[A_1_U1_A01_014], 1. Path | 3.25 | 20
EscapeRoute Door E1-03, 1. Path | Door E1-03, 1. Path | 0 | 2
EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path | Space E-Technik[A_1_U1_A01_015], 1. Path | 2.74 | 20
EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path | Space Haustechnik[A_1_U1_A01_016], 1. Path | 9.45 | 20
EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path | Space Stellplatz[A_1_U1_A01_001], 1. Path | 20.01 | 20
EscapeRoute Door E1-08, 1. Path | Door E1-08, 1. Path | 0 | 4
EscapeRoute Door E0-03, 1. Path | Door E0-03, 1. Path | 0 | 2
EscapeRoute Door E3-01, 1. Path | Door E3-01, 1. Path | 0 | 3
EscapeRoute Door E0-08, 1. Path | Door E0-08, 1. Path | 0 | 4
EscapeRoute Door E2-03, 1. Path | Door E2-03, 1. Path | 0 | 2

# IfcSpatialZone (122)
PredefinedType: TRANSPORT
Name | Description | CumulativePeople | Length (m) | Group
EscapeRouteSegment1 | Segment (2.676991838161407, 21.846968801897493, 5.92) -> (2.3564931383339087, 22.23074032690799, 5.92) | 3 | 0.5 | EscapeRoute Door E2-08, 1. Path
EscapeRouteSegment2 | Segment (2.3564931383339087, 22.23074032690799, 5.92) -> (0.3698086741010361, 23.48208408730245, 5.92) | 3 | 2.34793 | EscapeRoute Door E2-08, 1. Path
EscapeRouteSegment3 | Segment (0.3698086741010361, 23.48208408730245, 5.92) -> (-0.10595462487687493, 23.08453064246259, 5.976999999999999) | 8 | 0.622614 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment4 | Segment (-0.10595462487687493, 23.08453064246259, 5.976999999999999) -> (-0.2990940463638687, 22.92314493950735, 5.8) | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment5 | Segment (-0.2990940463638687, 22.92314493950735, 5.8) -> (-0.49223298422676376, 22.761759625208935, 5.622999999999999) | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment6 | Segment (-0.49223298422676376, 22.761759625208935, 5.622999999999999) -> (-0.6853722323663728, 22.600373696538863, 5.446) | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment7 | Segment (-0.6853722323663728, 22.600373696538863, 5.446) -> (-0.8785114953641194, 22.4389877399979, 5.269) | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment8 | Segment (-0.8785114953641194, 22.4389877399979, 5.269) -> (-1.071650231995089, 22.277602203134222, 5.092) | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment9 | Segment (-1.071650231995089, 22.277602203134222, 5.092) -> (-1.26478881232343, 22.116216460954664, 4.915) | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment10 | Segment (-1.26478881232343, 22.116216460954664, 4.915) -> (-1.4579277343750001, 21.954830078125, 4.7379999999999995) | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment11 | Segment (-1.4579277343750001, 21.954830078125, 4.7379999999999995) -> (-1.933694978988724, 21.557280186527052, 4.561) | 8 | 0.644771 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment12 | Segment (-1.933694978988724, 21.557280186527052, 4.561) -> (-3.0104024703982204, 22.42986223272499, 4.561) | 8 | 1.38589 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment13 | Segment (-3.0104024703982204, 22.42986223272499, 4.561) -> (-2.5231091553366043, 22.83701075623524, 4.561) | 8 | 0.635 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment14 | Segment (-2.5231091553366043, 22.83701075623524, 4.561) -> (-2.3299616411610033, 22.99838586550835, 4.383) | 8 | 0.308272 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment15 | Segment (-2.3299616411610033, 22.99838586550835, 4.383) -> (-2.1368137304171677, 23.159761622807117, 4.2059999999999995) | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment16 | Segment (-2.1368137304171677, 23.159761622807117, 4.2059999999999995) -> (-1.9436659042853188, 23.32113733527317, 4.029) | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment17 | Segment (-1.9436659042853188, 23.32113733527317, 4.029) -> (-1.7505185349741577, 23.482512690984002, 3.8520000000000003) | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment18 | Segment (-1.7505185349741577, 23.482512690984002, 3.8520000000000003) -> (-1.5573713088981926, 23.643888218130147, 3.6750000000000003) | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment19 | Segment (-1.5573713088981926, 23.643888218130147, 3.6750000000000003) -> (-1.3642237887227497, 23.805264333315183, 3.498) | 8 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment20 | Segment (-1.3642237887227497, 23.805264333315183, 3.498) -> (-1.171076749858885, 23.966640084531623, 3.321) | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment21 | Segment (-1.171076749858885, 23.966640084531623, 3.321) -> (-0.9779298794089698, 24.128016037318833, 3.144) | 8 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment22 | Segment (-0.9779298794089698, 24.128016037318833, 3.144) -> (-0.7847827148437501, 24.289392578125, 2.9170000000000003) | 8 | 0.338935 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment23 | Segment (-0.7847827148437501, 24.289392578125, 2.9170000000000003) -> (-0.30899528491482975, 24.686918127360507, 2.96) | 8 | 0.62149 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment24 | Segment (-0.30899528491482975, 24.686918127360507, 2.96) -> (0.3698086741010361, 23.48208408730245, 2.96) | 8 | 1.3829 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment25 | Segment (0.3698086741010361, 23.48208408730245, 2.96) -> (-0.10595462487687493, 23.08453064246259, 3.017) | 14 | 0.622614 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment26 | Segment (-0.10595462487687493, 23.08453064246259, 3.017) -> (-0.2990940463638687, 22.92314493950735, 2.8400000000000003) | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment27 | Segment (-0.2990940463638687, 22.92314493950735, 2.8400000000000003) -> (-0.49223298422676376, 22.761759625208935, 2.6630000000000003) | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment28 | Segment (-0.49223298422676376, 22.761759625208935, 2.6630000000000003) -> (-0.6853722323663728, 22.600373696538863, 2.486) | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment29 | Segment (-0.6853722323663728, 22.600373696538863, 2.486) -> (-0.8785114953641194, 22.4389877399979, 2.309) | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment30 | Segment (-0.8785114953641194, 22.4389877399979, 2.309) -> (-1.071650231995089, 22.277602203134222, 2.132) | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment31 | Segment (-1.071650231995089, 22.277602203134222, 2.132) -> (-1.26478881232343, 22.116216460954664, 1.955) | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment32 | Segment (-1.26478881232343, 22.116216460954664, 1.955) -> (-1.4579277343750001, 21.954830078125, 1.778) | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment33 | Segment (-1.4579277343750001, 21.954830078125, 1.778) -> (-1.933694978988724, 21.557280186527052, 1.601) | 14 | 0.644771 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment34 | Segment (-1.933694978988724, 21.557280186527052, 1.601) -> (-3.0104024703982204, 22.42986223272499, 1.601) | 14 | 1.38589 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment35 | Segment (-3.0104024703982204, 22.42986223272499, 1.601) -> (-2.5231091553366043, 22.83701075623524, 1.601) | 14 | 0.635 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment36 | Segment (-2.5231091553366043, 22.83701075623524, 1.601) -> (-2.3299616411610033, 22.99838586550835, 1.423) | 14 | 0.308272 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment37 | Segment (-2.3299616411610033, 22.99838586550835, 1.423) -> (-2.1368137304171677, 23.159761622807117, 1.246) | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment38 | Segment (-2.1368137304171677, 23.159761622807117, 1.246) -> (-1.9436659042853188, 23.32113733527317, 1.069) | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment39 | Segment (-1.9436659042853188, 23.32113733527317, 1.069) -> (-1.7505185349741577, 23.482512690984002, 0.8919999999999999) | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment40 | Segment (-1.7505185349741577, 23.482512690984002, 0.8919999999999999) -> (-1.5573713088981926, 23.643888218130147, 0.7150000000000001) | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment41 | Segment (-1.5573713088981926, 23.643888218130147, 0.7150000000000001) -> (-1.3642237887227497, 23.805264333315183, 0.538) | 14 | 0.307697 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment42 | Segment (-1.3642237887227497, 23.805264333315183, 0.538) -> (-1.171076749858885, 23.966640084531623, 0.361) | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment43 | Segment (-1.171076749858885, 23.966640084531623, 0.361) -> (-0.9779298794089698, 24.128016037318833, 0.184) | 14 | 0.307696 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment44 | Segment (-0.9779298794089698, 24.128016037318833, 0.184) -> (-0.7847827148437501, 24.289392578125, -0.042999999999999566) | 14 | 0.338935 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment45 | Segment (-0.7847827148437501, 24.289392578125, -0.042999999999999566) -> (-0.30899528491482975, 24.686918127360507, 0.0) | 14 | 0.62149 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment46 | Segment (-0.30899528491482975, 24.686918127360507, 0.0) -> (-0.2007842177146647, 25.172473455920464, 0.0) | 14 | 0.497467 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment47 | Segment (-0.2007842177146647, 25.172473455920464, 0.0) -> (-0.5213889780036004, 25.556156381889387, 0.0) | 120 | 0.5 | EscapeRoute Door E2-08, 1. Path; EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Door E1-03, 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path; EscapeRoute Door E1-08, 1. Path; EscapeRoute Door E0-03, 1. Path; EscapeRoute Door E3-01, 1. Path; EscapeRoute Door E0-08, 1. Path; EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment48 | Segment (11.201432881681647, 28.879231168338002, -3.3) -> (4.6153071296970705, 25.678424749741897, -3.3) | 20 | 7.32272 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRouteSegment49 | Segment (4.6153071296970705, 25.678424749741897, -3.3) -> (2.209914955599384, 24.386434926708326, -3.3) | 20 | 2.73041 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRouteSegment50 | Segment (2.209914955599384, 24.386434926708326, -3.3) -> (1.4425491036542317, 23.7452254061392, -3.3) | 20 | 1 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRouteSegment51 | Segment (1.4425491036542317, 23.7452254061392, -3.3) -> (-0.30899528491483313, 24.686918127360507, -3.2849999999999997) | 20 | 1.9887 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path
EscapeRouteSegment52 | Segment (-0.30899528491483313, 24.686918127360507, -3.2849999999999997) -> (-0.7847827148437515, 24.289392578125, -3.1079999999999997) | 100 | 0.644771 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment53 | Segment (-0.7847827148437515, 24.289392578125, -3.1079999999999997) -> (-0.974074457987039, 24.131237444921105, -2.946) | 100 | 0.295107 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment54 | Segment (-0.974074457987039, 24.131237444921105, -2.946) -> (-1.1633663903642488, 23.973082501680917, -2.77) | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment55 | Segment (-1.1633663903642488, 23.973082501680917, -2.77) -> (-1.352658844959599, 23.81492713385561, -2.593) | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment56 | Segment (-1.352658844959599, 23.81492713385561, -2.593) -> (-1.5419502846358377, 23.656772614003376, -2.416) | 100 | 0.3036 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment57 | Segment (-1.5419502846358377, 23.656772614003376, -2.416) -> (-1.7312427332761686, 23.498617275576397, -2.24) | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment58 | Segment (-1.7312427332761686, 23.498617275576397, -2.24) -> (-1.9205342329297188, 23.340462754458116, -2.063) | 100 | 0.3036 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment59 | Segment (-1.9205342329297188, 23.340462754458116, -2.063) -> (-2.1098267060574183, 23.182307445339408, -1.8860000000000001) | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment60 | Segment (-2.1098267060574183, 23.182307445339408, -1.8860000000000001) -> (-2.2991182070668645, 23.024152998895467, -1.71) | 100 | 0.303018 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment61 | Segment (-2.2991182070668645, 23.024152998895467, -1.71) -> (-2.488410717494341, 22.865997734420105, -1.533) | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment62 | Segment (-2.488410717494341, 22.865997734420105, -1.533) -> (-2.975705488836943, 22.458851375712193, -1.5330000000000001) | 100 | 0.634999 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment63 | Segment (-2.975705488836943, 22.458851375712193, -1.5330000000000001) -> (-2.118405232719287, 21.402935506180725, -1.5330000000000001) | 100 | 1.36012 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment64 | Segment (-2.118405232719287, 21.402935506180725, -1.5330000000000001) -> (-1.6426389770507812, 21.8004853515625, -1.356) | 100 | 0.64477 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment65 | Segment (-1.6426389770507812, 21.8004853515625, -1.356) -> (-1.453355434838725, 21.95865035004175, -1.18) | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment66 | Segment (-1.453355434838725, 21.95865035004175, -1.18) -> (-1.2640716438849755, 22.11681523344893, -1.003) | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment67 | Segment (-1.2640716438849755, 22.11681523344893, -1.003) -> (-1.0747877900421179, 22.27497985898414, -0.8260000000000001) | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment68 | Segment (-1.0747877900421179, 22.27497985898414, -0.8260000000000001) -> (-0.8855037115775211, 22.433144361790376, -0.6500000000000001) | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment69 | Segment (-0.8855037115775211, 22.433144361790376, -0.6500000000000001) -> (-0.6962195039911581, 22.591308637025385, -0.47300000000000003) | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment70 | Segment (-0.6962195039911581, 22.591308637025385, -0.47300000000000003) -> (-0.5069351370929565, 22.74947269421123, -0.29600000000000004) | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment71 | Segment (-0.5069351370929565, 22.74947269421123, -0.29600000000000004) -> (-0.31765059163822984, 22.907636565098958, -0.12) | 100 | 0.303019 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment72 | Segment (-0.31765059163822984, 22.907636565098958, -0.12) -> (-0.12836587537991645, 23.065800258966934, 0.056999999999999995) | 100 | 0.303601 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment73 | Segment (-0.12836587537991645, 23.065800258966934, 0.056999999999999995) -> (0.3473958633222677, 23.463355540560862, 0.0) | 100 | 0.622614 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment74 | Segment (0.3473958633222677, 23.463355540560862, 0.0) -> (-0.2007842177146647, 25.172473455920464, 0.0) | 100 | 1.79488 | EscapeRoute Space Einstellräume[A_1_U1_A01_013], 1. Path; EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path; EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path; EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment75 | Segment (5.6881233114173355, 24.27244642863435, -3.3) -> (3.123926989213119, 23.29259349543574, -3.3) | 20 | 2.74503 | EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path
EscapeRouteSegment76 | Segment (3.123926989213119, 23.29259349543574, -3.3) -> (2.3565611372679665, 22.65138397486661, -3.3) | 20 | 1 | EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path
EscapeRouteSegment77 | Segment (2.3565611372679665, 22.65138397486661, -3.3) -> (-0.30899528491483313, 24.686918127360507, -3.2849999999999997) | 20 | 3.35393 | EscapeRoute Space KIWA[A_1_U1_A01_014], 1. Path
EscapeRouteSegment78 | Segment (2.356563699308033, 23.48105316425547, 2.96) -> (1.9727286902096142, 23.160630496845037, 2.96) | 2 | 0.5 | EscapeRoute Door E1-03, 1. Path
EscapeRouteSegment79 | Segment (1.9727286902096142, 23.160630496845037, 2.96) -> (0.3698086741010361, 23.48208408730245, 2.96) | 2 | 1.63483 | EscapeRoute Door E1-03, 1. Path
EscapeRouteSegment80 | Segment (-1.1562513962711456, 21.145953385312023, -3.3) -> (1.0427310046349176, 21.556775720814258, -3.3) | 20 | 2.23703 | EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path
EscapeRouteSegment81 | Segment (1.0427310046349176, 21.556775720814258, -3.3) -> (1.8100968565768687, 22.197985241387215, -3.3) | 40 | 1 | EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment82 | Segment (1.8100968565768687, 22.197985241387215, -3.3) -> (-0.30899528491483313, 24.686918127360507, -3.2849999999999997) | 40 | 3.26888 | EscapeRoute Space E-Technik[A_1_U1_A01_015], 1. Path; EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment83 | Segment (-7.303881751396663, 19.604704826809808, -3.3) -> (-0.9239642235480416, 19.91017779858861, -3.3) | 20 | 6.38723 | EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment84 | Segment (-0.9239642235480416, 19.91017779858861, -3.3) -> (-0.15659837161339712, 20.551387319170313, -3.3) | 20 | 1 | EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment85 | Segment (-0.15659837161339712, 20.551387319170313, -3.3) -> (1.0427310046349176, 21.556775720814258, -3.3) | 20 | 1.56499 | EscapeRoute Space Haustechnik[A_1_U1_A01_016], 1. Path
EscapeRouteSegment86 | Segment (3.9974720814034037, 4.503918085773229, -3.3) -> (8.043232048952305, 7.884547978920625, -3.3) | 20 | 5.27227 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment87 | Segment (8.043232048952305, 7.884547978920625, -3.3) -> (8.064936429543183, 7.902684126889979, -3.3) | 20 | 0.0282843 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment88 | Segment (8.064936429543183, 7.902684126889979, -3.3) -> (2.9941615477811756, 21.178699902752633, -3.3) | 20 | 14.2115 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment89 | Segment (2.9941615477811756, 21.178699902752633, -3.3) -> (2.3529520272098865, 21.94606575469598, -3.3) | 20 | 1 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment90 | Segment (2.3529520272098865, 21.94606575469598, -3.3) -> (-0.30899528491483313, 24.686918127360507, -3.2849999999999997) | 20 | 3.82079 | EscapeRoute Space Stellplatz[A_1_U1_A01_001], 1. Path
EscapeRouteSegment91 | Segment (2.677091592442722, 21.846810225584857, 2.96) -> (2.356668925027129, 22.230645234678967, 2.96) | 4 | 0.5 | EscapeRoute Door E1-08, 1. Path
EscapeRouteSegment92 | Segment (2.356668925027129, 22.230645234678967, 2.96) -> (0.3698086741010361, 23.48208408730245, 2.96) | 4 | 2.34813 | EscapeRoute Door E1-08, 1. Path
EscapeRouteSegment93 | Segment (2.356563318091388, 23.481053126069256, 0.0) -> (1.9727283089929688, 23.160630458658822, 0.0) | 2 | 0.5 | EscapeRoute Door E0-03, 1. Path
EscapeRouteSegment94 | Segment (1.9727283089929688, 23.160630458658822, 0.0) -> (-0.2007842177146647, 25.172473455920464, 0.0) | 2 | 2.9617 | EscapeRoute Door E0-03, 1. Path
EscapeRouteSegment95 | Segment (1.9198991565706525, 22.93908512218241, 8.88) -> (1.5992943704331979, 23.322768026552353, 8.88) | 3 | 0.5 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment96 | Segment (1.5992943704331979, 23.322768026552353, 8.88) -> (0.3698086741010361, 23.48208408730245, 8.88) | 3 | 1.23976 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment97 | Segment (0.3698086741010361, 23.48208408730245, 8.88) -> (-0.10595462487687493, 23.08453064246259, 8.937) | 3 | 0.622614 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment98 | Segment (-0.10595462487687493, 23.08453064246259, 8.937) -> (-0.2990940463638687, 22.92314493950735, 8.76) | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment99 | Segment (-0.2990940463638687, 22.92314493950735, 8.76) -> (-0.49223298422676376, 22.761759625208935, 8.583) | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment100 | Segment (-0.49223298422676376, 22.761759625208935, 8.583) -> (-0.6853722323663728, 22.600373696538863, 8.406) | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment101 | Segment (-0.6853722323663728, 22.600373696538863, 8.406) -> (-0.8785114953641194, 22.4389877399979, 8.229) | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment102 | Segment (-0.8785114953641194, 22.4389877399979, 8.229) -> (-1.071650231995089, 22.277602203134222, 8.052) | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment103 | Segment (-1.071650231995089, 22.277602203134222, 8.052) -> (-1.26478881232343, 22.116216460954664, 7.875) | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment104 | Segment (-1.26478881232343, 22.116216460954664, 7.875) -> (-1.4579277343750001, 21.954830078125, 7.6979999999999995) | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment105 | Segment (-1.4579277343750001, 21.954830078125, 7.6979999999999995) -> (-1.933694978988724, 21.557280186527052, 7.521) | 3 | 0.644771 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment106 | Segment (-1.933694978988724, 21.557280186527052, 7.521) -> (-3.0104024703982204, 22.42986223272499, 7.521) | 3 | 1.38589 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment107 | Segment (-3.0104024703982204, 22.42986223272499, 7.521) -> (-2.5231091553366043, 22.83701075623524, 7.521) | 3 | 0.635 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment108 | Segment (-2.5231091553366043, 22.83701075623524, 7.521) -> (-2.3299616411610033, 22.99838586550835, 7.343) | 3 | 0.308272 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment109 | Segment (-2.3299616411610033, 22.99838586550835, 7.343) -> (-2.1368137304171677, 23.159761622807117, 7.1659999999999995) | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment110 | Segment (-2.1368137304171677, 23.159761622807117, 7.1659999999999995) -> (-1.9436659042853188, 23.32113733527317, 6.989) | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment111 | Segment (-1.9436659042853188, 23.32113733527317, 6.989) -> (-1.7505185349741577, 23.482512690984002, 6.811999999999999) | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment112 | Segment (-1.7505185349741577, 23.482512690984002, 6.811999999999999) -> (-1.5573713088981926, 23.643888218130147, 6.635) | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment113 | Segment (-1.5573713088981926, 23.643888218130147, 6.635) -> (-1.3642237887227497, 23.805264333315183, 6.457999999999999) | 3 | 0.307697 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment114 | Segment (-1.3642237887227497, 23.805264333315183, 6.457999999999999) -> (-1.171076749858885, 23.966640084531623, 6.281) | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment115 | Segment (-1.171076749858885, 23.966640084531623, 6.281) -> (-0.9779298794089698, 24.128016037318833, 6.104) | 3 | 0.307696 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment116 | Segment (-0.9779298794089698, 24.128016037318833, 6.104) -> (-0.7847827148437501, 24.289392578125, 5.877) | 3 | 0.338935 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment117 | Segment (-0.7847827148437501, 24.289392578125, 5.877) -> (-0.30899528491482975, 24.686918127360507, 5.92) | 3 | 0.62149 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment118 | Segment (-0.30899528491482975, 24.686918127360507, 5.92) -> (0.3698086741010361, 23.48208408730245, 5.92) | 3 | 1.3829 | EscapeRoute Door E3-01, 1. Path
EscapeRouteSegment119 | Segment (2.6770914919055078, 21.84681019618566, 0.0) -> (2.356668824489915, 22.23064520527977, 0.0) | 4 | 0.5 | EscapeRoute Door E0-08, 1. Path
EscapeRouteSegment120 | Segment (2.356668824489915, 22.23064520527977, 0.0) -> (-0.2007842177146647, 25.172473455920464, 0.0) | 4 | 3.89807 | EscapeRoute Door E0-08, 1. Path
EscapeRouteSegment121 | Segment (2.357506195895739, 23.481771475583475, 5.92) -> (1.9737283109258552, 23.161280391451573, 5.92) | 2 | 0.5 | EscapeRoute Door E2-03, 1. Path
EscapeRouteSegment122 | Segment (1.9737283109258552, 23.161280391451573, 5.92) -> (0.3698086741010361, 23.48208408730245, 5.92) | 2 | 1.63569 | EscapeRoute Door E2-03, 1. Path
